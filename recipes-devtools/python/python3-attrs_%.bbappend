PR:append = ".0"

BBCLASSEXTEND = "native nativesdk"
