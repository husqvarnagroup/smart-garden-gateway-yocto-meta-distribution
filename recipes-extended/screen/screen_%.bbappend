PR:append = ".0"

RDEPENDS_${PN} += "ncurses-terminfo-base"
