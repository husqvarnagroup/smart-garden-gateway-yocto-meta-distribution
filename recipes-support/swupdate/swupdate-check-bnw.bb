require swupdate-check.inc

PR = "${INC_PR}.0"

DISTRO_UPDATE_URL = "${DISTRO_UPDATE_URL_BASE}/gardena-update-image-bnw-${MACHINE}.swu"
