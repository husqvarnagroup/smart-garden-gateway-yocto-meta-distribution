PR_append = ".0"

RDEPENDS_${PN}_remove = "python3"
RDEPENDS_${PN}_append = " python3-core"
