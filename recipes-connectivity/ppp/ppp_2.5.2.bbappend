# Dummy file to prevent package version from going backwards.
# Remove once updating version 2.5.1 or newer.
PR:append = ".12"
